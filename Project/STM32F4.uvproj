# Keil uVision project STM32F4.uvproj, settings and files
target STM32F4 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F4 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__FPU_USED =1
  c include: ..\Libraries;..\Mylib;..\User;..\IMU;..\Vision;..\Mylib\BSP;..\Mylib\IMU;..\Mylib\Referee;..\Mylib\Task
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c OtherConfig.c
    ./: ReadMe.txt
  group BSP
    ../Mylib/BSP/: sys.c delay.c BootTask.c led.c CAN2.c Load_motor.c Shoot.c Remote.c my_func.c BKP_DATA.c MyWDG.c
  group Lib
    ../Libraries/: startup_stm32f40_41xxx.s misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_usart.c system_stm32f4xx.c stm32f4xx_iwdg.c stm32f4xx_i2c.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rtc.c stm32f4xx_tim.c stm32f4xx_dma.c
  group mpu6050
    ../Mylib/IMU/: imu.c 6050.c I2C.c Prepare_data.c
  group Task
    ../Mylib/Task/: clock.c Holder.c Chassis_Control.c Wheel_Speed.c Ramp.c Motor_out.c
  group Referee
    ../Mylib/Referee/: referee.c
  group VisionHit
    ../Vision/: Hit.c Hit_calculation.c
